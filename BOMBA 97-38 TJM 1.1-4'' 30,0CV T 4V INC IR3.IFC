Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: W:\PRODUTOS\SERIE CAM\97-38\IFC\BOMBA 97-38 TJM 1.1-4'' 30,0CV T 4V INC IR3.IFC
Time: 2026-06-08T13:34:55+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
